#include <SPI.h>
#include <MFRC522.h>
#include <LiquidCrystal.h>

// -------------------------
// RC522
// -------------------------
#define SS_PIN 10
#define RST_PIN 9

// -------------------------
// LED
// -------------------------
#define LED 2

// -------------------------
// LCD 16x2
// RS, E, D4, D5, D6, D7
// -------------------------
LiquidCrystal lcd(3, 4, 5, 6, 7, 8);

// -------------------------
// Lecteur RFID
// -------------------------
MFRC522 mfrc522(SS_PIN, RST_PIN);


// -------------------------
// SETUP
// -------------------------
void setup()
{
  // Moniteur série
  Serial.begin(9600);

  // SPI
  SPI.begin();

  // Initialisation RFID
  mfrc522.PCD_Init();

  // LED
  pinMode(LED, OUTPUT);
  digitalWrite(LED, LOW);

  // LCD
  lcd.begin(16, 2);

  // Message de démarrage
  lcd.clear();
  lcd.setCursor(0, 0);
  lcd.print("Lecteur RFID");

  lcd.setCursor(0, 1);
  lcd.print("Initialisation");

  Serial.println("-----------------------------");
  Serial.println("Lecteur RFID initialise");
  Serial.println("Approchez une carte...");
  Serial.println("-----------------------------");

  delay(2000);

  // Message d'attente
  lcd.clear();
  lcd.setCursor(0, 0);
  lcd.print("Approchez votre");

  lcd.setCursor(0, 1);
  lcd.print("carte RFID");
}


// -------------------------
// LOOP
// -------------------------
void loop()
{
  // Vérifier si une nouvelle carte est présente
  if (!mfrc522.PICC_IsNewCardPresent())
  {
    return;
  }

  // Vérifier si la carte peut être lue
  if (!mfrc522.PICC_ReadCardSerial())
  {
    return;
  }


  // -------------------------
  // Carte détectée
  // -------------------------

  Serial.println();
  Serial.println("Carte RFID detectee !");
  Serial.print("UID : ");


  // Affichage LCD
  lcd.clear();
  lcd.setCursor(0, 0);
  lcd.print("UID recu par");
  lcd.setCursor(0, 1);
  lcd.print("Arduino");


  // -------------------------
  // Affichage UID
  // -------------------------

  for (byte i = 0; i < mfrc522.uid.size; i++)
  {
    // Moniteur série
    if (mfrc522.uid.uidByte[i] < 0x10)
    {
      Serial.print("0");
    }

    Serial.print(mfrc522.uid.uidByte[i], HEX);
    Serial.print(" ");

  }

  Serial.println();


  // -------------------------
  // Afficher l'UID sur LCD
  // -------------------------

  delay(1500);

  lcd.clear();
  lcd.setCursor(0, 0);
  lcd.print("UID:");

  lcd.setCursor(0, 1);

  for (byte i = 0; i < mfrc522.uid.size; i++)
  {
    if (mfrc522.uid.uidByte[i] < 0x10)
    {
      lcd.print("0");
    }

    lcd.print(mfrc522.uid.uidByte[i], HEX);
    lcd.print(" ");
  }


  // -------------------------
  // LED
  // -------------------------

  digitalWrite(LED, HIGH);

  delay(5000);

  digitalWrite(LED, LOW);


  // -------------------------
  // Retour écran attente
  // -------------------------

  lcd.clear();

  lcd.setCursor(0, 0);
  lcd.print("Approchez votre");

  lcd.setCursor(0, 1);
  lcd.print("carte RFID");


  // Arrêt communication RFID
  mfrc522.PICC_HaltA();
  mfrc522.PCD_StopCrypto1();
}# -PROJET-SMARTBUS

